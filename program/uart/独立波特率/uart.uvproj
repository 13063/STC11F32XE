# Keil uVision project uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c public.c public.h uart.c uart.h
